Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-03-20T16:24:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Mar 20 16:24:11 2018* Host: NCL-PI12* Database: C:\Users\KunduR\AppData\Local\Temp\{CD4DB14B-27F7-4FAC-9E7F-B560D9D37E02}\ifc* Database version: 5507* Database creation date: Tue Mar 20 16:24:10 2018* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Mar 20 16:24:11 2018* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Mar 20 16:24:11 2018* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDoor: 300x300mm, NBS_ProfabAccessLtd_AcsPnls_Profab1000MD:300x300mm:303419
In: Level 0
Type - ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_36_01 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_ProfabAccessLtd_AccessPanels_Profab1000MD_300x300mm; ManufacturerName: Profab Access Ltd; ManufacturerURL: www.profabaccesspanels.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/gikbsnyd; NBSDescription: Access panels; NBSReference: 45-45-00/310; OmniClassCode: 22-08 31 16; OmniClassTitle: Access Panels and Frames; OmniClassVersion: Table 22 2012-05-16; ProductInformation: www.profabaccesspanels.co.uk/access-panels/metal-access-panels-for-ceilings-and-walls; Revision: n/a; Uniclass2015Code: Pr_30_59_36_01; Uniclass2015Title: Access panels; Uniclass2015Version: Products v1.9; Version: 3
Type - NBS_Data - ClearAccessSize: 245 x 260 mm; Frame: 1.2 mm thick electro-galvanized carbon steel; FrameDepth: 34 mm; FrameOptions: Beaded frame (BF), Dutch foled frame (DFF), Deep plaster frame (PDF), Exposed edge frame (EEF), Picture frame (PF); IntegralAccessories: CAD (Controlled Action Device), Safety chords; LatchOrLockType: Budget lock (BL); LockingOptions: Budget lock (BL), Push catch (PC), Security lock (SL); LockNumber: 1; Operation: Concealed pivot hinge outward opening; PanelIntegralFinish: Powder coated; PanelType: 0.9 mm thick electro-galvanized carbon steel; Position: Ceiling or wall mounted; Weight: 2.5 kg
Type - Pset_DoorCommon - AcousticRating: n/a; DurabilityRating: n/a; FireExit: no; FireRating: n/a; GlazingAreaFraction: 0; HandicapAccessible: no; HasDrive: no; HygrothermalRating: n/a; Infiltration: 0; IsExternal: no; MechanicalLoadRating: n/a; Reference: n/a; SecurityRating: n/a; SelfClosing: no; SmokeStop: no; ThermalTransmittance: 0; WaterTightnessRating: n/a; WindLoadRating: n/a
Type - IFC - IfcExportAs: IfcDoorType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_36_01:Access panels; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Metal access panels for ceiling and walls; DurationUnit: year; ExpectedLife: n/a; Features: Foam strip to prevent rattle on leading edge of door, Simple pivot device for easy door removal; Finish: n/a; Grade: n/a; Manufacturer: technical@profabaccess.com; Material: Carbon steel; ModelNumber: n/a; ModelReference: Profab 1000MD; Name: AccessPanels_Profab1000MD_300x300mm_ProfabAccessLtd; NominalHeight: 300 mm; NominalLength: 300 mm; NominalWidth: 300 mm; ReplacementCost: n/a; Shape: n/a; Size: 300 x 300 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OverallHeight: 604.8 mm; OverallWidth: 337.6 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
